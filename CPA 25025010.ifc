Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: C:\Users\Usuario\Desktop\JOMBAR\MUESTRAS B.I.M\IFC\CPA 25025010.ifc
Time: 2017-01-19T19:45:05
Written by: ACCA_IFC.dll Version 200
Made in: Edificius 8.00c

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (mm) | NominalHeight (mm)
TERRENO | -1500 | 1000
Cimentación | -500 | 500
Planta Baja | 0 | 3200
Cubierta | 3200 | 0

# IfcFurnishingElement: CALZO LISO, CPA 25025010
In: Planta Baja
Description: CALZO GRANDES CARGAS; Material: Color_01
PROPIEDADES TÉRMICAS - TEMPERATURA H.D.T.: 67ºC (ISO 306/VICAT B); TEMPERATURA DE SERVICIO LARGO PLAZO: -50...80ºC MEDIA; TEMPERATURA DE SERVICIO CORTO LAZO: 100ºC MEDIA; CONDUCTIVIDAD TÉRMICA: 0,40 W/(m*K) (DIN 52612-1); CAPACIDAD TÉRMICA: 1,90 KJ/(Kg*K) (DIN 52612); COEFICIENTE DE EXPANSIÓN TÉRMICA LINEAL: 150-230 10-6K-1 (DIN 53752)
PROPIEDADES GENERALES - DENSIDAD: 0,96 g/cm3 (ISO 1183-1); TEMPERATURA MÁXIMA ALMACENAMIENTO: 60º C; RESISTENCIA QUÍMICA: GRAN RESISTENCIA; RADIACIÓN ULTRAVIOLETA: BUENO; COLOR STANDARD: NEGRO; CLASIFICACION MRS: ISO TR 9080; INFLAMABILIDAD (ESPESORES 3/6mm): UL 94; ABSORCIÓN DE AGUA: <0,01% (ISO 62); COMPOSICIÓN: COMPOSITE POLIETILENO; PESO POR UNIDAD: 600 g
Pset_ManufacturerTypeInformation - ArticleNumber: CALZO GRANDES CARGAS; ModelReference: CPA 25025010; ModelLabel: CPA 25025010; Manufacturer: JOMBAR; ProductionYear: 2017
PROPIEDADES MECÁNICAS - MÓDULO ELASTICIDAD YOUNG: 1000 MPa (ISO 178); RESISTENCIA AL IMPACTO CHARPY CON MUESCA: >16 KJ/m2 (ISO 179) NO ROMPE; RESISTENCIA A LA COMPRESIÓN: >100 MPa (ISO 604) NO ROMPE; DEFORMACIÓN A FUERZA MAXIMA DE ELONGACIÓN: >50% (ISO 527); DEFORMACIÓN A STRESS DE ELONGACIÓN: 10% (ISO 527); CARGA MÁXIMA POR cm2: 1000 Kg
